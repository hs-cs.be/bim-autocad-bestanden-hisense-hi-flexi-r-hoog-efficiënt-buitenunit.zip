Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-01-25T12:11:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 25 12:11:41 2018 * Host: b3robrawr2682 * Database: C:\Users\cn\AppData\Local\Temp\{E0658971-F6A6-489B-A9CA-E8CFFF032C37}\ifc * Database version: 5507 * Database creation date: Thu Jan 25 12:11:40 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Jan 25 12:11:40 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 25 12:11:40 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVWT-96FESRA, HC_Heat Pump_MEPcontent_Hisense_AVWT76FESRA-154FESSA_INT-EN:AVWT-96FESRA:1310513
In: V00
Type - Material: Color RGB 216-216-216, Color RGB 024-077-198, Color RGB 080-080-080, Color RGB 000-204-204
Type - Dimensions - Depth: 765 mm; Drain Diameter: 32 mm; Height: 1720 mm; Refrigerant Gas Diameter: 19 mm; Refrigerant Gas Diameter Low Pressure: 22.2 mm; Refrigerant Liquid Diameter: 9.53 mm; Width: 950 mm
Type - Electrical - ELB Nominal Current: 40 A; Hertz: 50 Hz; Maximum Circuit Ampacity (A): 20; Maximum Running Current: 23 A; Phase: 3; Voltage: 400 V
Type - Identity Data - Article Description: Heat pump outdoor unit; Article Type: AVWT-96FESRA; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 3.0; ETIM Article Class: EC001213; Family Version: 11.11; Manufacturer: Hisense; Manufacturer Art. No.: AVWT-96FESRA; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVWT-96FESRA; OmniClass Number: 23.75.10.21; OmniClass Title: Heat Pumps; Product Line: Hi-Flexi R Series; Revit Version: 2016; Type Name: AVWT-96FESRA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 024-077-198; Green: Color RGB 000-204-204; Grey: Color RGB 080-080-080; White: Color RGB 216-216-216
Type - Mechanical - Drain Fixture Units: 0 m3/s
Type - Mechanical - Loads - Airflow Rate (m3/min): 175; Compressor Motor Output (kW): 0.08; Cooling Capacity (kW): 28; Cooling EER (kW/kW): 4.02; Cooling Power Input (kW): 6.97; External Static Pessure (Pa): 0; Fan Motor Output (kW): 0.49; Heating Capacity (kW): 31.5; Heating COP (kW/kW): 4.38; Heating Power Input (kW): 7.19; Sound Pressure Level (dB(A)): 60; Unit Weight (kg): 246
Type - Other - Category: Mechanical Equipment; Compressor Quantity: 1; Compressor Type: Inverter scroll hermetic compressor; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVWT76FESRA-154FESSA_INT-EN; Fan Quantity: 1; Fan Type: Axial-flow Fan; Gap Distance: 298 mm; Gas Line: 155 mm; Indoor Unit Model/Quantity: 7 to 16; Indoor Unit Total Capacity: 50 to 140% of outdoor unit capacity; Liquid Line: 155 mm; Protection Devices High Pressure (MPa): High pressure sensor, High pressure switch at 4.15; Protection Devices Inverter Circuit (COMP./FAN): Over-heat protection, Over-current protection; Refrigerant Charge (kg): 9.9; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 15.6697 m2; Volume: 7.92041 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Flow Refrigerant Gas: 0 m3/s; Flow Refrigerant Gas Low Pressure: 0 m3/s; Flow Refrigerant Liquid: 0 m3/s; System Classification: Power,Undefined,Sanitary,Undefined
Other - Back Clearance Safe: 300 mm; Elevation: 300 mm; Family: HC_Heat Pump_MEPcontent_Hisense_AVWT76FESRA-154FESSA_INT-EN: AVWT-96FESRA; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVWT76FESRA-154FESSA_INT-EN: AVWT-96FESRA; Front Clearance Safe: 500 mm; Left Clearance Safe: 200 mm; Right Clearance Safe: 200 mm; Top Clearance Safe: 1500 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVWT76FESRA-154FESSA_INT-EN: AVWT-96FESRA; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVWT76FESRA-154FESSA_INT-EN: AVWT-96FESRA
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 300 mm; Front Clearance: 500 mm; Left Clearance: 200 mm; Right Clearance: 200 mm; Service Space: no; Top Clearance: 1500 mm
